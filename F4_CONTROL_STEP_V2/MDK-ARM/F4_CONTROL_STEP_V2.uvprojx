# Keil uVision project F4_CONTROL_STEP_V2.uvprojx, settings and files
target F4_CONTROL_STEP_V2 (6190000::V6.19::.\ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F4_CONTROL_STEP_V2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Lib/Button;../Lib/Flash;../Lib/ILI9341;../Lib/Keypad;../Lib/User;../Lib/Encoder
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Lib/Button
    ../Lib/Button/: button.c
  group Lib/Flash
    ../Lib/Flash/: flash.c
  group Lib/ILI9341
    ../Lib/ILI9341/: ILI9341_GFX.c ILI9341_STM32_Driver.c mainTFT.h
  group Lib/Keypad
    ../Lib/Keypad/: KEYPAD.c KEYPAD_cfg.c
  group Lib/Encoder
    ../Lib/Encoder/: encoder.c
  group Lib/User
    ../Lib/User/: Button_user.c ILI9431_user.c Keypad_user.c step_user.c Flash_user.c user_ex.h
software components: CMSIS:CORE 5.6.0
