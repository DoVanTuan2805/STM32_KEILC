<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\C6_DRIVER_ARDUINO.ewp</path>
  </project>
  <batchBuild />
</workspace>
