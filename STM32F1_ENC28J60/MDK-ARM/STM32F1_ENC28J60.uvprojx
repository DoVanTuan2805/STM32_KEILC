# Keil uVision project STM32F1_ENC28J60.uvprojx, settings and files
target STM32F1_ENC28J60 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F1_ENC28J60 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Lib;..\lwip-2.1.2\lwip-2.1.2\src\api;..\lwip-2.1.2\lwip-2.1.2\src\apps;..\lwip-2.1.2\lwip-2.1.2\src\core;..\lwip-2.1.2\lwip-2.1.2\src\include;..\lwip-2.1.2\lwip-2.1.2\src\netif;..\lwip-2.1.2\lwip-2.1.2\src\apps\http;..\lwip-2.1.2\lwip-2.1.2\src\core\ipv4;..\lwip-2.1.2\lwip-2.1.2\src\include\compat;..\lwip-2.1.2\lwip-2.1.2\src\include\lwip;..\lwip-2.1.2\lwip-2.1.2\src\include\netif;..\lwip-2.1.2\lwip-2.1.2\src\include\compat\posix;..\lwip-2.1.2\lwip-2.1.2\src\include\compat\stdc;..\lwip-2.1.2\lwip-2.1.2\src\include\lwip\apps;..\lwip-2.1.2\lwip-2.1.2\src\include\lwip\priv;..\lwip-2.1.2\lwip-2.1.2\src\include\lwip\prot;..\Core\lwip_user;..\Core\lwip_user\arch;..\Core\lwip_user\noOS;..\Lib;..\MQTT;..\app_debug;..\SEGGER_RTT_V698b\RTT
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Lib/: uart.c enc28j60.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group lwip/api
    ../lwip-2.1.2/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/apps
    ../lwip-2.1.2/lwip-2.1.2/src/apps/mqtt/: mqtt.c
  group lwip/core
    ../lwip-2.1.2/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/netif
    ../lwip-2.1.2/lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/ipv4
    ../lwip-2.1.2/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/porting
    ../Core/lwip_user/: lwip_user.c
    ../Core/lwip_user/noOS/: ethernetif.c
    ../Core/lwip_user/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h lwipopts.h perf.h sys_arch.h
  group MQTT
    ../MQTT/: mqtt_client.c
  group appdebug
    ../app_debug/: app_debug.c
  group SEGGER_RTT_V698b
    ../SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0
