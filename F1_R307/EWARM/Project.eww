<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F1_R307.ewp</path>
  </project>
  <batchBuild />
</workspace>
