<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F4_DWIN_ETH_SIM.ewp</path>
  </project>
  <batchBuild />
</workspace>
