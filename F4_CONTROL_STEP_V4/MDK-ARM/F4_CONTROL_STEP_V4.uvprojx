# Keil uVision project F4_CONTROL_STEP_V4.uvprojx, settings and files
target F4_CONTROL_STEP_V4 (6190000::V6.19::.\ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F4_CONTROL_STEP_V4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application/ak/inc;../application/ak/src;../application/app;../application/common;../application/common/container;../application/platform;../application/task;../application/sys;../application/libraries/ILI9341;../application/task/screens;../application/libraries/Encoder;../application/libraries/Keypad;../application/libraries/Flash;../application/libraries/Button
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group ak
    ../application/ak/src/: fsm.c message.c task.c timer.c tsm.c
  group app
    ../application/app/: app.c task_list.c app_encoder.c app_keypad.c app_bsp.c
  group common
    ../application/common/: cmd_line.c utils.c xprintf.c
    ../application/common/container/: fifo.c log_queue.c ring_buffer.c
  group platform
    ../application/platform/: platform.c io_cfg.c system.c pgmspace.h
  group task
    ../application/task/: task_life.c task_keypad.c task_flash.c task_step.c
    ../application/task/screens/: scr_start_up.c scr_device.c
  group ILI9341
    ../application/libraries/ILI9341/: ILI9341_GFX.c ILI9341_STM32_Driver.c view_manager.c logo.h
  group Encoder
    ../application/libraries/Encoder/: encoder.c encoder_config.h
  group Keypad
    ../application/libraries/Keypad/: KEYPAD.c KEYPAD_cfg.c
  group Flash
    ../application/libraries/Flash/: flash.c
  group Button
    ../application/libraries/Button/: button.c
software components: CMSIS:CORE 6.0.0
