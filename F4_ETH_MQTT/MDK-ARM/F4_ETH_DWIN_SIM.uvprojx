# Keil uVision project F4_ETH_DWIN_SIM.uvprojx, settings and files
target F4_ETH_DWIN_SIM (6190000::V6.19::.\ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F4_ETH_DWIN_SIM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../lwip-2.1.2/lwip_user;../lwip-2.1.2/lwip_user/arch;../lwip-2.1.2/lwip_user/noOS;../lwip-2.1.2/lwip-2.1.2/src/api;../lwip-2.1.2/lwip-2.1.2/src/apps;../lwip-2.1.2/lwip-2.1.2/src/core;../lwip-2.1.2/lwip-2.1.2/src/include;../lwip-2.1.2/lwip-2.1.2/src/netif;../lwip-2.1.2/lwip-2.1.2/src/apps/mqtt;../lwip-2.1.2/lwip-2.1.2/src/apps/http;../lwip-2.1.2/lwip-2.1.2/src/core/ipv4;../lwip-2.1.2/lwip-2.1.2/src/netif/ppp;../lwip-2.1.2/lwip-2.1.2/src/include/compat;../lwip-2.1.2/lwip-2.1.2/src/include/compat/posix;../lwip-2.1.2/lwip-2.1.2/src/include/compat/stdc;../lwip-2.1.2/lwip-2.1.2/src/include/lwip/apps;../lwip-2.1.2/lwip-2.1.2/src/include/lwip/priv;../lwip-2.1.2/lwip-2.1.2/src/include/lwip/prot;../Lib/ENC28J60;../Lib/MQTT;../Lib/SIM;../Lib/Button
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lwIP/api
    ../lwip-2.1.2/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/apps
    ../lwip-2.1.2/lwip-2.1.2/src/apps/mqtt/: mqtt.c
  group lwIP/core
    ../lwip-2.1.2/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwIP/netif
    ../lwip-2.1.2/lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwIP/ipv4
    ../lwip-2.1.2/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwIP/porting
    ../lwip-2.1.2/lwip_user/: lwip_user.c
    ../lwip-2.1.2/lwip_user/noOS/: ethernetif.c
    ../lwip-2.1.2/lwip_user/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h lwipopts.h perf.h sys_arch.h
  group Lib/ENC28J60
    ../Lib/ENC28J60/: enc28j60.c uart.c
  group Lib/MQTT
    ../Lib/MQTT/: mqtt_client.c
  group Lib/SIM
    ../Lib/SIM/: A7860C_command.c MQTT_Sim_Config.c
  group Lib/Button
    ../Lib/Button/: button.c
software components: CMSIS:CORE 5.6.0
